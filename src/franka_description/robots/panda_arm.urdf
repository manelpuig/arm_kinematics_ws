Commit message: moveit correction 1

File: src/franka_description/robots/panda_arm.urdf (robot description, URDF)
Before this commit: robot panda, 12 links, 11 joints
Links:
- added link dummy
Joints:
- added joint dummy_joint: type fixed, parent dummy, child panda_link0
